# IAR project controller.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\lib\stdperiph\inc; ..\controller; ..\common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: controller.bin
  ILINK.IlinkOutputFile: controller.out
  ILINK.IlinkIcfFile: icf\lnkstm8l151g6_bootloader_app.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
configuration Debug standalone (STM8, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: controller_standalone.hex
  ILINK.IlinkOutputFile: controller_standalone.out
configuration Release standalone (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
  OBJCOPY.OOCOutputFile: controller_standalone.hex
  ILINK.IlinkOutputFile: controller_standalone.out
configuration Debug hex (STM8, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: controller.hex
  ILINK.IlinkOutputFile: controller_hex.out
configuration Release hex (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
  OBJCOPY.OOCOutputFile: controller.hex
  ILINK.IlinkOutputFile: controller_hex.out
  group lib/stdperiph
    ../lib/stdperiph/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group src
    ../controller/: i2c.c knob.c led.c main.c standalone.c startup.c stm8l15x_it.c
