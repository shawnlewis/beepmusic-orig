# IAR project bootloader.ewp, settings and files
configuration Debug - B3_main (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.PreInclude: ..\bootloader\bootloader_b3_main.h
  ICCSTM8.CCIncludePath2: ..\lib\stdperiph\inc; ..\bootloader; ..\common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader_b3_main.hex
  ILINK.IlinkOutputFile: bootloader_b3_main.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release - B3_main (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
configuration Debug - Demo board (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  ICCSTM8.PreInclude: ..\bootloader\bootloader_demo_board.h
  OBJCOPY.OOCOutputFile: bootloader_demo_board.hex
  ILINK.IlinkOutputFile: bootloader_demo_board.out
configuration Release - Demo board (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD
  ICCSTM8.PreInclude: ..\bootloader\bootloader_demo_board.h
  OBJCOPY.OOCOutputFile: bootloader_demo_board.hex
  ILINK.IlinkOutputFile: bootloader_demo_board.out
  group common
    ../common/: iomcu_checksum.c
  group customization
    ../bootloader/: bootloader_b3_main.c bootloader_demo_board.c
  group lib/stdperiph
    ../lib/stdperiph/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group src
    ../bootloader/: commands.c flash.c i2c.c main.c stm8l15x_intvec.s
